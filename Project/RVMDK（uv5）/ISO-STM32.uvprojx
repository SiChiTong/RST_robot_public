# Keil uVision project ISO-STM32.uvprojx, settings and files
target 巡检机器人 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xunjianjiqiren +hex
  AfterMake: fromelf --bin --output ./Objects/xunjianjiqiren.bin  ./Objects/xunjianjiqiren.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\User;..\..\User\APP;..\..\User\BSP;..\..\User\BSP\led;..\..\User\uC-CPU;..\..\User\uC-CPU\ARM-Cortex-M3\RealView;..\..\User\uC-LIB;..\..\User\uCOS-III\Source;..\..\User\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\User\BSP\pwm;..\..\User\BSP\usart;..\..\User\BSP\ESP8266;..\..\User\BSP\Common;..\..\User\BSP\Huoer_exti;..\..\User\BSP\TIM;..\..\User\BSP\bsp_adc;..\..\User\BSP\ds18b20;..\..\User\BSP\Agreement;..\..\User\BSP\i2c;..\..\User\BSP\Distance_exti;..\..\User\BSP\485;..\..\User\BSP\light_sensor;..\..\User\BSP\iwdg;..\..\User\BSP\task;..\..\User\BSP\AdvanceTim;..\..\User\BSP\Variable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group APP
    ../../User/APP/: app.c app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP
    ../../User/BSP/: bsp.c bsp.h
    ../../User/BSP/led/: bsp_led.c
    ../../User/BSP/pwm/: bsp_tim_pwm.c
    ../../User/BSP/usart/: bsp_usart.c
    ../../User/BSP/ESP8266/: bsp_esp8266.c
    ../../User/BSP/Common/: bsp_Common.c
    ../../User/BSP/Huoer_exti/: Huoer_exti.c
    ../../User/BSP/bsp_adc/: bsp_adc.c
    ../../User/BSP/ds18b20/: bsp_ds18b20.c
    ../../User/BSP/TIM/: bsp_tim.c
    ../../User/BSP/Agreement/: bsp_Agreement.c
    ../../User/BSP/i2c/: bsp_i2c_ee.c
    ../../User/BSP/485/: bsp_485.c crc16.c bsp_modbusrtu.c
    ../../User/BSP/light_sensor/: bsp_light_exit.c
    ../../User/BSP/iwdg/: bsp_iwdg.c
    ../../User/BSP/task/: bsp_task.c
    ../../User/BSP/AdvanceTim/: bsp_AdvanceTim.c
    ../../User/BSP/Variable/: bsp_variable.c
  group uC/CPU
    ../../User/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
    ../../User/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uC/LIB
    ../../User/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../User/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../../User/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III Port
    ../../User/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
